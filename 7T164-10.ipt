# Autodesk Inventor part: 7T164-10_uzsakovui
## iProperties
Created: 2006-12
Part Number: 7T164-10_uzsakovui
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
